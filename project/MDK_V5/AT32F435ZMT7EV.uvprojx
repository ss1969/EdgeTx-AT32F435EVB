# Keil uVision project AT32F435ZMT7EV.uvprojx, settings and files
target AT32F435ZMT7EV (6240000::V6.24::ARMCLANG)
  device: -AT32F435ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.4
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F435ZMT7EV +hex
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: AT32F435ZMT7, USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c at32f435_437_wk_config.c main.c wk_system.c wk_acc.c wk_exint.c wk_qspi.c wk_spi.c wk_usart.c wk_usb_otgfs.c wk_gpio.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_gpio.c at32f435_437_usart.c at32f435_437_pwc.c at32f435_437_spi.c at32f435_437_debug.c at32f435_437_flash.c at32f435_437_exint.c at32f435_437_misc.c at32f435_437_scfg.c at32f435_437_usb.c at32f435_437_acc.c at32f435_437_qspi.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
